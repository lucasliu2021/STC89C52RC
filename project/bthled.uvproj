# Keil uVision project bthled.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: bthled +hex
  c flags: Optimize=8 SizeSpeed=1
  group user
    ./: STARTUP.A51
    ./src/: main3.c
